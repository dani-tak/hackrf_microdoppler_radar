options:
  parameters:
    author: Adi
    description: CW Doppler motion detector (one HackRF). Close the window to stop cleanly.
    generate_options: qt_gui
    id: rx_microdoppler_fan_2p4ghz
    output_language: python
    title: rx micro-Doppler + motion (2.4 GHz)
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: rx_bb_gain
  id: variable
  parameters:
    value: '24'
  states: {}
- name: rx_if_gain
  id: variable_qtgui_range
  parameters:
    label: RX IF gain (dB)
    start: '0'
    step: '1'
    stop: '40'
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    label: Trigger threshold
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.5'
  states: {}
- name: tone_freq
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1e-10'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: fast - slow
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: thresh
    init: '0'
    low: thresh*0.8
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-tone_freq'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 10e3, 5e3)
    type: ccf
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=1
    bb_gain0: rx_bb_gain
    freq0: rf_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rx_if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate/decim
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    name: Tone health (FFT)
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: Motion strength
    size: '1024'
    srate: samp_rate/decim/100
    type: float
    ylabel: ''
    yunit: ''
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: Trigger (1)
    size: '1024'
    srate: samp_rate/decim/100
    type: float
    ylabel: ''
    ymax: '1.2'
    ymin: '-0.2'
    yunit: ''
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.005'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-5'
    type: float
  states: {}
- name: single_pole_iir_filter_xx_2
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.05'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: complex 50k -> 1k
    cutoff_freq: '400'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate/decim
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: Micro-Doppler (1 kHz)
    fftsize: '256'
    freqhalf: 'False'
    fc: '0'
    bw: samp_rate/decim/50
    int_min: '-100'
    int_max: '-10'
    grid: 'True'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: raw complex baseband @1kHz
    file: microdoppler_fan_2p4ghz.cf32
    type: complex
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [blocks_abs_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_keep_one_in_n_0, '0', single_pole_iir_filter_xx_2, '0']
- [blocks_nlog10_ff_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_nlog10_ff_0, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_sub_xx_0, '0', blocks_abs_xx_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_sub_xx_0, '1']
- [single_pole_iir_filter_xx_2, '0', blocks_threshold_ff_0, '0']
- [single_pole_iir_filter_xx_2, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
